# Keil uVision project ocosv7_IV3530.uvprojx, settings and files
target U503 ram (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1061CVL5A NXP
  pack: NXP.MIMXRT1061_DFP.12.1.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x0c0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: gpt_timer.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CPU_MIMXRT1061CVL5A,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1
  c misc: --library_interface=armcc --diag_suppress=1296,186
  c include: ..\app_code\inc;..\lib_src\bsp\include;..\lib_src\CMSIS\Include;..\lib_src\components;..\lib_src\MIMXRT1061\drivers;..\lib_src\MIMXRT1061\utilities;..\lib_src\xip;..\act;..\act\dic;..\CAN;..\EleCtrlCode;..\hydr;..\IL3;..\lib_src;..\sys;..\sysconfig;..\usercfg
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: ..\lib_src\MIMXRT1061\arm\MIMXRT1061_ram.scf
  link misc: --remove
  group act
    ../app/act/: act.c actctrl.c actfork.c AdBios.c adjust.c admeter.c airblow.c alarm.c autoctrl.c cfgfork.c charge.c clamp.c clampcls.c clampopn.c core.c crc16.c da.c DaBios.c dlink.c eject.c inject.c IOproc.c keycmd.c lub.c machine.c memtbl.c mergsort.c motor.c nozzle.c oil.c part.c prot.c protcmd.c recycle.c robot.c safedoor.c ServoEcat.c SRAM.C suckback.c uart.c useract.c ZeroDebug.c TempCtrlComm.c TempCtrlMw.c tempctrl.c injstor.c AiClampopn.c shut.c sysacc.c lock.c chargpress.c power.c udpctrl.c coreprotect.c
  group sys
    ../app/sys/: acttbl.c cfgdb.c factorycfg.c main.c monmmi.c printf.c systempro.c tbl.c version.c virtest.c part_info.c AutoRunWithOutServo.c CalibrationAggControl.c PressSelfLearn.C AlarmClass.c
  group CAN
    ../app/CAN/: can_e702.c can2.c canother.c canrx.c cantx.c can_e502.c
  group hydr
    ../app/hydr/: hydr.C movectrl.C servo.C Pump.c HydrPos.c OilPortTB.c ServFive.C
  group EleCtrlCode
    ../app/EleCtrlCode/: EleCtrlApp.c EtherCATProc.c
  group ECAT
    ../hwdrv/hw_src/ecat_master/: app_config.c app_data.c app_driver_func.c datagram.c device.c domain.c ec_app_interface.c ec_init.c ec_mm.c eth_op.c ethernet.c fmmu_config.c foe_request.c fsm_change.c fsm_coe.c fsm_foe.c fsm_master.c fsm_pdo.c fsm_pdo_entry.c fsm_sii.c fsm_slave.c fsm_slave_config.c fsm_slave_scan.c fsm_soe.c mailbox.c master.c module.c pdo.c pdo_entry.c pdo_list.c sdo.c sdo_entry.c sdo_request.c slave.c slave_config.c soe_errors.c soe_request.c sync.c sync_config.c uart_printf.c voe_handler.c
    ../hwdrv/hw_src/ecat_proc/: ecat_m7_timer.c
    ../hwdrv/hw_src/m7_ecat_hal/: ecat_hal.c fsl_phy.c
  group device
    ../hwdrv/hw_src/components/: generic_list.c lpuart_adapter.c serial_manager.c serial_port_uart.c
    ../hwdrv/hw_src/MIMXRT1061/: system_MIMXRT1061.c
    ../hwdrv/hw_src/MIMXRT1061/arm/: startup_MIMXRT1061.s
    ../hwdrv/hw_src/MIMXRT1061/utilities/: fsl_assert.c fsl_debug_console.c fsl_notifier.c fsl_shell.c fsl_str.c fsl_debug_console.h fsl_debug_console_conf.h fsl_notifier.h fsl_shell.h fsl_str.h
  group drivers
    ../hwdrv/hw_src/bsp/: board.c bsp_can.c bsp_flash.c bsp_key_it.c bsp_led.c bsp_lpi2c.c bsp_nvic .c bsp_sram.c bsp_systick.c bsp_uart.c clock_config.c gpt_timer.c pin_mux.c wdog.c
    ../hwdrv/hw_src/MIMXRT1061/drivers/: fsl_clock.c fsl_gpt.c fsl_gpio.c fsl_common.c fsl_lpuart.c fsl_semc.c fsl_lpi2c.c fsl_flexcan.c fsl_wdog.c fsl_flexspi.c fsl_enet.c
    ../hwdrv/hw_src/: LM73.c cpld.c
    ../hwdrv/hw_isr/: HwISR.c
    ../hwdrv/hw_mid/: hwmid.c
  group cm_backtrace
    ../hwdrv/hw_src/cm_backtrace/: cm_backtrace.c
    ../hwdrv/hw_src/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group DM9000
    ../hwdrv/hw_src/bsp/dm9k_lwip/HARDWARE/DM9000/: dm9000.c
    ../hwdrv/hw_src/bsp/dm9k_lwip/LWIP/arch/: sys_arch.c
    ../hwdrv/hw_src/bsp/dm9k_lwip/LWIP/lwip_app/lwip_comm/: lwip_comm.c
    ../hwdrv/hw_src/bsp/dm9k_lwip/LWIP/lwip_app/tcp_client_demo/: tcp_client_demo.c
    ../hwdrv/hw_src/bsp/dm9k_lwip/LWIP/lwip_app/udp_demo/: udp_demo.c
    ../hwdrv/hw_src/bsp/dm9k_lwip/LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../hwdrv/hw_src/bsp/dm9k_lwip/LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../hwdrv/hw_src/bsp/dm9k_lwip/LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c lwip_sys.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../hwdrv/hw_src/bsp/dm9k_lwip/LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
    ../hwdrv/hw_src/bsp/dm9k_lwip/MALLOC/: malloc.c
  group lib
    ../app/lib/: ApiCommon.c MD_memtbl.c M7-00-07-HydrPosApi.lib
target U503 flexspi_nor (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MIMXRT1061CVL5A NXP
  pack: NXP.MIMXRT1061_DFP.12.1.0
  cpu: as above
  output: U503.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1061CVL5A
  c misc: --library_interface=armcc --diag_suppress=66,1296,186 --diag_suppress=1296,186
  c include: ..\lib_src\bsp\include;..\lib_src\CMSIS\Include;..\lib_src\components;..\lib_src\MIMXRT1061\drivers;..\lib_src\MIMXRT1061\utilities;..\lib_src\xip;..\usercfg;..\act;..\CAN;..\hydr;..\lib_src;..\sys;..\sysconfig;..\act\dic;..\EleCtrlCode;..\IL3;..\lib_src\ecat_master;..\lib_src\ecat_proc;..\lib_src\m7_ecat_hal
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: ..\lib_src\MIMXRT1061\arm\MIMXRT1061_flexspi_nor.scf
  link misc: --remove --keep=*(.boot_hdr.ivt) --keep=*(.boot_hdr.boot_data) --keep=*(.boot_hdr.conf) --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
target U503 flexspi_nor_ram (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1061CVL5A NXP
  pack: NXP.MIMXRT1061_DFP.12.1.0
  cpu: as above
  output: U503_n2r
  AfterMake: fromelf --bincombined -o .\iven-352110001000.bin "$L@L.axf"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: XIP_BOOT_HEADER_DCD_ENABLE =1,USE_RAM_VECTOR_TABLE,CPU_MIMXRT1061CVL5A,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1,XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1 HW_MODEL=MODEL_I3521
  c misc: --library_interface=armcc --diag_suppress=1296,186
  c include: ..\app\act;..\app\act\dic;..\app\CAN;..\app\EleCtrlCode;..\app\hydr;..\app\IL3;..\app\sys;..\app\sysconfig;..\app\usercfg;..\hwdrv\hw_mid;..\hwdrv\hw_src\bsp\include;..\hwdrv\hw_src\components;..\hwdrv\hw_src\MIMXRT1061\drivers;..\hwdrv\hw_src\MIMXRT1061\utilities;..\hwdrv\hw_src\xip;..\hwdrv\hw_src\ecat_master;..\hwdrv\hw_src\ecat_proc;..\hwdrv\hw_src\m7_ecat_hal;..\hwdrv\hw_src\CMSIS\Include;..\hwdrv\hw_src;..\hwdrv\hw_isr;..\hwdrv\hw_src\bsp\include;..\app\lib;..\app\cm_backtrace;C:\Keil_v5\ARM\ARMCC\include;..\hwdrv\hw_src\bsp\dm9k_lwip;..\hwdrv\hw_src\bsp\dm9k_lwip\HARDWARE;..\hwdrv\hw_src\bsp\dm9k_lwip\LWIP;..\hwdrv\hw_src\bsp\dm9k_lwip\LWIP\arch;..\hwdrv\hw_src\bsp\dm9k_lwip\LWIP\lwip-1.4.1\src\include;..\hwdrv\hw_src\bsp\dm9k_lwip\LWIP\lwip-1.4.1\src\include\ipv4;..\hwdrv\hw_src\bsp\dm9k_lwip\LWIP\lwip-1.4.1\src\include\netif;..\hwdrv\hw_src\bsp\dm9k_lwip\LWIP\lwip_app\lwip_comm;..\hwdrv\hw_src\bsp\dm9k_lwip\MALLOC;..\hwdrv\hw_src\bsp\dm9k_lwip\HARDWARE\DM9000;..\hwdrv\hw_src\bsp\dm9k_lwip\LWIP\lwip_app\tcp_client_demo;..\hwdrv\hw_src\bsp\dm9k_lwip\LWIP\lwip_app\udp_demo
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: ..\hwdrv\hw_src\MIMXRT1061\arm\MIMXRT1061_nor_txt_ram.scf
  link misc: --remove
